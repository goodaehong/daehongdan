#include <opencv2/opencv.hpp>
#include <iostream>

int main() {
    // ─────────────────────────────────────────────
    // 1) 카메라 RTSP 주소 (VLC에서 성공한 그 주소)
    //    아래 <비번> 부분을 실제 비밀번호로 바꿔줘.
    //    IP나 채널 번호(/0/)도 네 것에 맞게 확인.
    // ─────────────────────────────────────────────
    std::string url = "rtsp://admin:<비번>@172.20.35.118:554/0/profile2/media.smp";

    // ─────────────────────────────────────────────
    // 2) 카메라에 연결 (RTSP 요청 대화는 OpenCV가 알아서)
    // ─────────────────────────────────────────────
    cv::VideoCapture cap(url);

    // 연결 됐는지 확인
    if (!cap.isOpened()) {
        std::cerr << "카메라 연결 실패! 주소/비번/네트워크 확인.\n";
        return -1;
    }
    std::cout << "카메라 연결 성공! ESC 누르면 종료.\n";

    // ─────────────────────────────────────────────
    // 3) 프레임을 계속 받아서 창에 표시
    // ─────────────────────────────────────────────
    cv::Mat frame;   // 그림 한 장이 담길 그릇
    while (true) {
        // 프레임 한 장 받기 (패킷 수신 + 디코딩 전부 여기서 자동)
        bool ok = cap.read(frame);

        if (!ok || frame.empty()) {
            std::cerr << "프레임 못 받음. 연결이 끊겼을 수 있음.\n";
            break;
        }

        // 받은 그림을 창에 표시
        cv::imshow("RTSP Channel 0", frame);

        // 1ms 대기하며 키 입력 확인. ESC(27) 누르면 종료.
        if (cv::waitKey(1) == 27) {
            break;
        }
    }

    // ─────────────────────────────────────────────
    // 4) 정리
    // ─────────────────────────────────────────────
    cap.release();              // 카메라 연결 해제
    cv::destroyAllWindows();    // 창 닫기
    std::cout << "종료.\n";
    return 0;
}
